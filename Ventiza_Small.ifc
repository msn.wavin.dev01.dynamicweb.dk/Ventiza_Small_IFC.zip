Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Ventiza Small.ifc
Time: 2026-06-28T15:19:38
Author: Wavin
Organization: Wavin
Written by: Codex dummy IFC generator
Made in: Wavin Ventiza configurator

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy (5)
In: Default Storey
PredefinedType: USERDEFINED
Name
Ventiza Small Dummy BIM Object | Description: Simplified Ventiza ventilation unit for configurator downloads; Pset_WavinVentizaCommon - Manufacturer: Wavin; Model: Ventiza Small; Width: 560 mm; Depth: 550 mm; Height: 650 mm; Weight: 18 kg; SupplyAirConnector: SUP - Supply Air; ExtractAirConnector: ETA - Extract Air; ExhaustAirConnector: EHA - Exhaust Air; OutdoorAirConnector: ODA - Outdoor Air; DuctConnectionDiameter: 160 mm; SupplyVoltage: 230V 50/60 Hz; IngressProtectionClass: IP31; DocumentFolder: /Files/Digital assets/Wavin/Small
Supply Air SUP
Extract Air ETA
Outdoor Air ODA
Exhaust Air EHA
